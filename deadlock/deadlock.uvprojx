# Keil uVision project deadlock.uvprojx, settings and files
target deadlock (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: deadlock
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_LM4F120H5QR DEADLOCK
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --symdefs deadlock.def
  group Source
    ./: startup.s eFile.c ff.c loader.c deadlock.c bankers.c
    ../inc/: LaunchPad.c PLL.c ADCT0ATrigger.c ADCSWTrigger.c LPF.c IRDistance.c WTimer0A.c Timer2A.c Timer3A.c Timer4A.c Timer1A.c Timer0A.c
    ../common/: OS.c ST7735.c Interpreter.c UART0int.c eDisk.c osasm.s ADC.c heap.c FIFOsimple.c
